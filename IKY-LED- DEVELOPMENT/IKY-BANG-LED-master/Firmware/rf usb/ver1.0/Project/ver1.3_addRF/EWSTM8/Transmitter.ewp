# IAR project Transmitter.ewp, settings and files
configuration DEBUG (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; DEBUG_MODE
  ICCSTM8.CCIncludePath2: ..\; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: IKY_BANG_LED_RF_USB.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RELEASE (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: C:\Users\dvhai_000\Google Drive\IKY Company\IKY_4M\SourceCode\IKY_4M_151208\Remote_0xEB\Remote\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Project\STM8L15x_StdPeriph_Auto_Time_300615; C:\Users\dvhai_000\Google Drive\IKY Company\IKY_4M\SourceCode\IKY_4M_151208\Remote_0xEB\Remote\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: remote_v1_0.hex
configuration RELEASE-ADMIN (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L05X_LD_VL; TAG_ADMIN
  ICCSTM8.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: remote_v1_0.hex
configuration RELEASE-TESTING (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L05X_LD_VL; FOR_TEST
  ICCSTM8.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: remote_v1_0.hex
  group STM8L15x_StdPeriph_Driver
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group User
    ../: main.c rf_packet.c ringbuf.c softuart.c stm8l15x_it.c sys_tick.c uart1.c uart_parser.c
