# Keil uVision project IKY_COUNTDOWN.uvprojx, settings and files
target DEBUG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IKY_SLED_1_0_3 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, DEBUG_MODE1 NRF_LOG_USES_RTT=1
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\_user\inc;..\..\fat_sd;.\_default;..\..\lib;.\_user\src;.\_lib;.\P5Matrix;.\P10Matrix;.\RGBmatrixPanel;.\SEGGER_RTT_V612a\Application;.\SEGGER_RTT_V612a\RTT;.\SEGGER_RTT_V612a\Syscalls;.\stm32_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CoreM3
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Application
    ./_user/src/: hw_config.c main.c system_config.c stm32f10x_it.c display_task.c uart_parser.c
  group System driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_cec.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_crc.c stm32f10x_exti.c
  group radio
    ./_user/src/: cc1101.c cc1101_receiver.c cc1101_parser.c
  group Lib
    ../../lib/: tick.c ringbuf.c sys_tick.c uart1.c uart2.c uart3.c
    ./stm32_lib/: button.c exti.c
  group P10Matrix
    ./P10Matrix/: font.c p10matrix_rgb.c framebuffer.c p10matrix.c
  group SEGGER_RTT
    ./SEGGER_RTT_V612a/Application/: RTT_Log.c
    ./SEGGER_RTT_V612a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./SEGGER_RTT_V612a/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
