# IAR project GPS_RFID_READER.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; DEBUG_MODE; SYSCLK_FREQ_16MHz
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPS_RFID_READER.hex
  ILINK.IlinkOutputFile: STM8S003.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: stm8s_conf.h stm8s_it.h
  group Source Files
    ../src/: h_string.c io_control.c main.c rfid_decode.c rfid_report.c stm8s_it.c uart1.c
  group STM8S_StdPeriph_Driver
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
